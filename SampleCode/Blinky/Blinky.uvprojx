# Keil uVision project Blinky.uvprojx, settings and files
target M487KMCAN Flash (6160000::V6.16::ARMCLANG)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.13
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: M487KMCAN
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x20018000 size 0x10000
  group Source
    ./: Blinky.c main.c
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, CMSIS Driver:VIO:Board 1.0.1, Device:StdDriver:CLK 1.0.0, Device:StdDriver:GPIO 1.0.0, Device:StdDriver:SYS 1.0.0, Device:Startup 0.00.001
